# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: ..\HEX\project +hex
  link misc: REMOVEUNUSED
  group USER
    ../USER/: main.c platform.c params.c tasks.c control.c debug1.c
  group APP
    ../APP/: app.c app_di.c app_do.c app_delay.c app_timer.c app_eeprom.c app_utils.c app_wdt.c app_ai.c app_nrf24l01.c app_motor.c app_mpu6050.c app_iic.c app_bmp280.c app_pid.c
  group README
    ../README/: 1.NOTICE.txt 2.PROJECT LOG.txt 3.DESCRIPTION OF DESIGN.txt
